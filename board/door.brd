# Repository StudioAquatan/DigitHackDoor

## EAGLE design board/door.brd

Parts:
C1, C3, C4: C-EU050-024X044; C050-024X044
C6, C7: CPOL-EUE5-4; E5-4
CN1: S2B-PH-K-S
IC3: 7805; TO220_V
JP1, JP2: PINHD-1X10; 1X10
JP3, JP4: PINHD-1X2/90; 1X02/90
LED1, LED2: LEDSML0603; SML0603
R2, R3: 1k; 0207/10
S3: 10-XX; B3F-10XX

Connections:
+3V3: C1.1, C4.1, C7.+, IC3.3 (OUT), JP1.1, R2.2
+8V: C3.1, C6.+, CN1.1, IC3.1 (IN)
A: LED2.A, R2.1
B: LED1.A, R3.1
GND: C1.2, C3.2, C4.2, C6.-, C7.-, CN1.2, IC3.2 (GND), JP1.9, JP2.1, JP2.9, JP3.1, JP4.1, LED1.C, LED2.C, S3.3, S3.4 (P1)
IO12: JP1.4, JP3.2
IO13: JP1.5, JP4.2
IO14: JP1.3, S3.1 (S), S3.2 (S1)
LED: JP2.5, R3.2

Notes on the sheet:
ESP8826モジュールのシールド
ReadSwitch

Board: 2 copper layers, 28.8 x 38.5 mm, 16 parts (0 on the bottom side), 9 nets.

## Commit log

2018-05-25 add board
2018-05-25 add user_button
2018-06-06 add arduino program
2018-06-08 fix path
2018-06-08 refactor
2018-06-08 ignore setting.h
2018-06-08 post処理を追加
2018-06-08 ドア開閉判定を修正
